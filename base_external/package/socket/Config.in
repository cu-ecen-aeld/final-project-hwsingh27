## base_external/package/socket/Config.in
```kconfig
config BR2_PACKAGE_SOCKET
	bool "socket"
	help
	  Includes the client and server files for socket communication.
```
